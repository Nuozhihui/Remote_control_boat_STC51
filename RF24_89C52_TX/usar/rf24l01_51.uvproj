# Keil uVision project rf24l01_51.uvproj, settings and files
target rf24l01_51 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: rf24l01_51 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Include
  link misc: REMOVEUNUSED
  group usar
    ./: STARTUP.A51 main.c
  group common
    ../Common/: delay.c uart.c spi.c oled.c RF24L01.c
